# Keil uVision project project.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743IIKx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx,USE_USB_HS
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\User\bsp\inc;..\..\User;..\..\User\bsp;..\..\User\fonts;..\..\User\images;..\..\User\app\inc;..\..\Libraries\FatFs\src;..\..\Libraries\FatFs\src\drivers;..\..\Libraries\LwIP\src\include;..\..\Libraries\LwIP\src\apps;..\..\Libraries\LwIP\system;..\..\Libraries\LwIP\phy_drv;..\..\User\lwip_if;..\..\User\lwip_http;..\..\User\lwip_tcp;..\..\Libraries\STM32_USB_Device_Library\Core\Inc;..\..\Libraries\STM32_USB_Device_Library\Class\MSC\Inc;..\..\User\modbus;..\..\User\programmer;..\..\User\lua\src;..\..\User\lua\if;..\..\User\usbd_mass_storage;..\..\Libraries\STM32_USB_Device_Library\Class\CDC\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32-v7.sct
  group App
    ../../User/app/src/: main.c param.c status_logic.c wifi_if.c status_system_set.c status_menu.c lcd_menu.c demo_sd_fatfs.c
  group BSP
    ../../User/bsp/: bsp.h bsp.c stm32h7xx_it.c bsp_msg.c
    ../../User/bsp/src/: bsp_user_lib.c bsp_timer.c bsp_led.c bsp_key.c bsp_tim_pwm.c bsp_i2c_eeprom_24xx.c bsp_i2c_gpio.c bsp_tft_lcd.c bsp_beep.c bsp_spi_bus.c bsp_cpu_adc.c bsp_cpu_dac.c bsp_can.c bsp_tft_st7735.c bsp_tft_st7789.c bsp_i2c_mcp4018.c bsp_power_tvcc.c bsp_fmc_io.c bsp_uart_fifo.c bsp_period_ctrl.c bsp_tim_dma.c bsp_tim_capture.c bsp_cpu_flash.c bsp_esp32_at.c bsp_i2c_mcp4725.c bsp_qspi_w25q256.c bsp_cpu_rtc.c bsp_74hc595_io.c bsp_emmc.c
  group MDK-ARM
    ./: startup_stm32h743xx.s
  group HAL_Driver
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_sdmmc.c stm32h7xx_hal_fdcan.c stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_gpio.c stm32h7xx_hal_adc.c stm32h7xx_hal_spi.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_sram.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sdram.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_hcd.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_rtc.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_pcd.c stm32h7xx_ll_usb.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_nand.c stm32h7xx_hal_sai.c stm32h7xx_hal_eth.c stm32h7xx_hal_pwr_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_lptim.c stm32h7xx_hal_nor.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_mmc.c
    ../../User/bsp/: stm32h7xx_hal_conf.h
  group CMSIS
    ../../User/bsp/: system_stm32h7xx.c
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerMDK/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt 03.通信协议.txt 04.Lua开发.txt
  group Fonts
    ../../User/fonts/: asc12.c asc16.c asc24.c asc32.c hz12.c hz16.c hz24.c hz32.c ra8875_asc_width.c asc62x40.c asc96x40.c
  group Images
    ../../User/images/: ADC.c Camera.c ChiLun.c chujiao.c FM.c GPS.c hwinfo.c images.h LCD.c MP3.c Phone.c radio.c Recorder.c USBDisk.c web.c Wireless.c
  group FatFS
    ../../Libraries/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../Libraries/FatFs/src/option/: syscall.c cc936.c
    ../../Libraries/FatFs/src/drivers/: emmc_diskio_dma.c
  group USB_Device_Library_Core
    ../../Libraries/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group USB_Device_Library_Class
    ../../Libraries/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../Libraries/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group USBD_Virtual_COM
    ../../User/usbd_virtual_com/: usbd_cdc_interface.c usbd_conf.c usbd_desc.c usbd_it.c usbd_user.c
  group USBD_Mass Storage
    ../../User/usbd_mass_storage/: usbd_conf.c usbd_desc.c usbd_it.c usbd_storage.c usbd_usr.c
  group LwIP
    ../../Libraries/LwIP/src/netif/: ethernet.c
    ../../Libraries/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../Libraries/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../Libraries/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group LwIP_PhyDrv
    ../../Libraries/LwIP/phy_drv/: lan8742.c
  group LwIP_IF
    ../../User/lwip_if/: app_ethernet.c ethernetif.c lwipopts.h lwip_user.c net_udp.c
  group LwIP_HTTP
    ../../Libraries/LwIP/src/apps/httpd/: fs.c httpd.c
    ../../User/lwip_http/: http_cgi_ssi.h httpd_cgi_ssi.c
  group LwIP_TCP
    ../../User/lwip_tcp/: tcp_echoclient.c tcp_echoserver.c
  group Modbus
    ../../User/modbus/: modbus_iap.c modbus_slave.c modbus_register.c modbus_reg_addr.h
  group Programmer
    ../../User/programmer/: prog_if.c
  group Lua src 5.3.5
    ../../User/lua/src/: lapi.c lauxlib.c lbaselib.c lbitlib.c lcode.c lcorolib.c lctype.c ldblib.c ldebug.c ldo.c ldump.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c loslib.c lparser.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lundump.c lutf8lib.c lvm.c lzio.c
  group Lua_IF
    ../../User/lua/if/: lua_if.c lua_if_gpio.c lua_if_i2c.c lua_if_spi.c lua_if_tcp_udp.c lua_if_tim.c lua_if_qspi.c lua_if_fatfs.c
  group DAP_usb
    ../../User/daplink/source/usb/: usb_lib.c usbd_core.c
    ../../User/daplink/source/usb/winusb/: usbd_core_winusb.c
    ../../User/daplink/source/usb/webusb/: usbd_core_webusb.c
    ../../User/daplink/source/usb/msc/: usbd_core_msc.c usbd_msc.c
    ../../User/daplink/source/usb/hid/: usbd_core_hid.c usbd_hid.c usbd_user_hid.c
    ../../User/daplink/source/usb/cdc/: usbd_cdc_acm.c usbd_core_cdc.c
    ../../User/daplink/source/usb/bulk/: usbd_bulk.c
  group DAP_Link
    ../../User/daplink/source/family/st/stm32f746zg/: flash_blob.c target.c
    ../../User/daplink/source/target/: target_board.c target_family.c
    ../../User/daplink/source/rtos_none/: cmsis_os2_port.c SysTick_Handler.c
    ../../User/daplink/source/hic_hal/stm32/stm32f103xb/: usb_config.c usbd_STM32F103.c sdk.c
    ../../User/daplink/source/daplink/interface/: bootloader_update.c daplink.c main.c swd_host.c swd_host_ca.c target_flash.c
  group DAP_CMSIS-DAP
    ../../User/daplink/source/daplink/cmsis-dap/: DAP.c DAP_queue.c DAP_vendor.c JTAG_DP.c SW_DP.c SWO.c
